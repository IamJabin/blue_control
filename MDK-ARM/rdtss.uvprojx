# Keil uVision project rdtss.uvprojx, settings and files
target N32WB03x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB031 Nationstech
  pack: Nationstech.N32WB03X_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(64000000) ELITTLE
  output: rdts_ble +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: N32WB03X, USE_STDPERIPH_DRIVER
  c include: ..\App;..\BSP;..\firmware;..\middlewares;..\App\inc;..\App\src;..\App\inc\app_profile;..\App\src\app_profile;..\firmware\CMSIS;..\firmware\n32wb03x_std_periph_driver;..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\firmware\CMSIS\device\startup;..\firmware\n32wb03x_std_periph_driver\inc;..\firmware\n32wb03x_std_periph_driver\src;..\MDK-ARM;.\Listings;.\Objects;..\middlewares\Nationstech;..\middlewares\Third_Party;..\middlewares\Nationstech\ble_library;..\middlewares\Nationstech\ble_library\ns_ble_profile;..\middlewares\Nationstech\ble_library\ns_ble_stack;..\middlewares\Nationstech\ble_library\ns_library;..\middlewares\Third_Party\FreeRTOS;..\middlewares\Third_Party\FreeRTOS\License;..\middlewares\Third_Party\FreeRTOS\Source;..\middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\middlewares\Third_Party\FreeRTOS\Source\include;..\middlewares\Third_Party\FreeRTOS\Source\portable;..\middlewares\Third_Party\FreeRTOS\Source\portable\Common;..\middlewares\Third_Party\FreeRTOS\Source\portable\IAR;..\middlewares\Third_Party\FreeRTOS\Source\portable\Keil;..\middlewares\Third_Party\FreeRTOS\Source\portable\MemMang;..\middlewares\Third_Party\FreeRTOS\Source\portable\RVDS;..\middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM0;..\middlewares\Nationstech\ble_library\ns_ble_profile\anc;..\middlewares\Nationstech\ble_library\ns_ble_profile\anc\ancc;..\middlewares\Nationstech\ble_library\ns_ble_profile\anc\ancc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\anc\ancc\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\anp;..\middlewares\Nationstech\ble_library\ns_ble_profile\anp\anpc;..\middlewares\Nationstech\ble_library\ns_ble_profile\anp\anps;..\middlewares\Nationstech\ble_library\ns_ble_profile\anp\anpc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\anp\anpc\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\anp\anps\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\anp\anps\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\bas\basc;..\middlewares\Nationstech\ble_library\ns_ble_profile\bas\bass;..\middlewares\Nationstech\ble_library\ns_ble_profile\bas\basc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\bas\basc\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\bas\bass\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\bas\bass\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\bcs\bcsc;..\middlewares\Nationstech\ble_library\ns_ble_profile\bcs\bcss;..\middlewares\Nationstech\ble_library\ns_ble_profile\bcs\bcsc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\bcs\bcsc\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\blp\blpc;..\middlewares\Nationstech\ble_library\ns_ble_profile\blp\blps;..\middlewares\Nationstech\ble_library\ns_ble_profile\blp\blpc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\blp\blpc\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\blp\blps\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\blp\blps\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\cgmp\cgmc;..\middlewares\Nationstech\ble_library\ns_ble_profile\cgmp\cgms;..\middlewares\Nationstech\ble_library\ns_ble_profile\cgmp\cgmc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\cgmp\cgmc\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\cgmp\cgms\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\cgmp\cgms\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\cpp\cppc;..\middlewares\Nationstech\ble_library\ns_ble_profile\cpp\cpps;..\middlewares\Nationstech\ble_library\ns_ble_profile\cpp\cppc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\cpp\cppc\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\cpp\cpps\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\cpp\cpps\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\cscp\cscpc;..\middlewares\Nationstech\ble_library\ns_ble_profile\cscp\cscps;..\middlewares\Nationstech\ble_library\ns_ble_profile\cscp\cscpc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\cscp\cscpc\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\cscp\cscps\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\cscp\cscps\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\dis\disc;..\middlewares\Nationstech\ble_library\ns_ble_profile\dis\diss;..\middlewares\Nationstech\ble_library\ns_ble_profile\dis\disc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\dis\disc\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\dis\diss\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\dis\diss\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\find\findl;..\middlewares\Nationstech\ble_library\ns_ble_profile\find\findt;..\middlewares\Nationstech\ble_library\ns_ble_profile\find\findl\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\find\findl\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\find\findt\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\find\findt\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\glp\glpc;..\middlewares\Nationstech\ble_library\ns_ble_profile\glp\glps;..\middlewares\Nationstech\ble_library\ns_ble_profile\glp\glpc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\glp\glpc\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\glp\glps\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\glp\glps\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogpbh;..\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogpd;..\middlewares\Nationstech\ble_library\ns_ble_stack\arch;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules;..\middlewares\Nationstech\ble_library\ns_ble_stack\rfinit;..\middlewares\Nationstech\ble_library\ns_ble_stack\stack_common;..\middlewares\Nationstech\ble_library\ns_ble_stack\symdef;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ahi;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\em;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\hci;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\sch;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ahi\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\inc;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\llc;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\lld;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\llm;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\em;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\em\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\hci;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\hci\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\sch;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\sch\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogprh;..\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogpbh\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogpbh\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogpd\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogpd\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogprh\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogprh\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\hrp\hrpc;..\middlewares\Nationstech\ble_library\ns_ble_profile\hrp\hrps;..\middlewares\Nationstech\ble_library\ns_ble_profile\hrp\hrpc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\hrp\hrpc\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\hrp\hrps\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\hrp\hrps\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\htp\htpc;..\middlewares\Nationstech\ble_library\ns_ble_profile\htp\htpt;..\middlewares\Nationstech\ble_library\ns_ble_profile\htp\htpc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\htp\htpc\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\htp\htpt\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\htp\htpt\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\lan\lanc;..\middlewares\Nationstech\ble_library\ns_ble_profile\lan\lans;..\middlewares\Nationstech\ble_library\ns_ble_profile\lan\lanc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\lan\lanc\src;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\aes;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\dbg;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\ecc_p256;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\h4tl;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\ke;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\rwip;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\aes\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\dbg\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\ecc_p256\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\h4tl\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\ke\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\rwip\api;..\middlewares\Nationstech\ble_library\ns_ble_stack\rfinit\api;..\middlewares\Nationstech\ble_library\ns_library\adv;..\middlewares\Nationstech\ble_library\ns_library\ble;..\middlewares\Nationstech\ble_library\ns_library\delay;..\middlewares\Nationstech\ble_library\ns_library\dfu;..\middlewares\Nationstech\ble_library\ns_library\ecc;..\middlewares\Nationstech\ble_library\ns_library\error;..\middlewares\Nationstech\ble_library\ns_library\log;..\middlewares\Nationstech\ble_library\ns_library\scheduler;..\middlewares\Nationstech\ble_library\ns_library\sec;..\middlewares\Nationstech\ble_library\ns_library\sleep;..\middlewares\Nationstech\ble_library\ns_library\timer;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\att;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\gap;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\gatt;..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\l2c;..\middlewares\Nationstech\ble_library\ns_ble_profile\ns_ius;..\middlewares\Nationstech\ble_library\ns_ble_profile\ns_ius\ns_iuss;..\middlewares\Nationstech\ble_library\ns_ble_profile\ns_ius\ns_iuss\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\ns_ius\ns_iuss\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\pasp;..\middlewares\Nationstech\ble_library\ns_ble_profile\pasp\paspc;..\middlewares\Nationstech\ble_library\ns_ble_profile\pasp\pasps;..\middlewares\Nationstech\ble_library\ns_ble_profile\pasp\paspc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\pasp\paspc\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\pasp\pasps\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\pasp\pasps\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\plxp;..\middlewares\Nationstech\ble_library\ns_ble_profile\plxp\plxc;..\middlewares\Nationstech\ble_library\ns_ble_profile\plxp\plxc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\plxp\plxc\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\plxp\plxs;..\middlewares\Nationstech\ble_library\ns_ble_profile\plxp\plxs\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\plxp\plxs\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\prox;..\middlewares\Nationstech\ble_library\ns_ble_profile\prox\proxm;..\middlewares\Nationstech\ble_library\ns_ble_profile\prox\proxr;..\middlewares\Nationstech\ble_library\ns_ble_profile\prox\proxm\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\prox\proxm\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\prox\proxr\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\prox\proxr\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\rdts;..\middlewares\Nationstech\ble_library\ns_ble_profile\rdts\rdtsc;..\middlewares\Nationstech\ble_library\ns_ble_profile\rdts\rdtss;..\middlewares\Nationstech\ble_library\ns_ble_profile\rdts\rdtsc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\rdts\rdtsc\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\rdts\rdtss\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\rdts\rdtss\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\rscp;..\middlewares\Nationstech\ble_library\ns_ble_profile\rscp\rscpc;..\middlewares\Nationstech\ble_library\ns_ble_profile\rscp\rscps;..\middlewares\Nationstech\ble_library\ns_ble_profile\rscp\rscpc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\rscp\rscpc\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\rscp\rscps\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\rscp\rscps\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\scpp;..\middlewares\Nationstech\ble_library\ns_ble_profile\scpp\scppc;..\middlewares\Nationstech\ble_library\ns_ble_profile\scpp\scpps;..\middlewares\Nationstech\ble_library\ns_ble_profile\scpp\scppc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\scpp\scppc\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\scpp\scpps\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\scpp\scpps\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\tip;..\middlewares\Nationstech\ble_library\ns_ble_profile\tip\tipc;..\middlewares\Nationstech\ble_library\ns_ble_profile\tip\tips;..\middlewares\Nationstech\ble_library\ns_ble_profile\tip\tipc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\tip\tipc\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\tip\tips\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\tip\tips\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\uds;..\middlewares\Nationstech\ble_library\ns_ble_profile\uds\udsc;..\middlewares\Nationstech\ble_library\ns_ble_profile\uds\udss;..\middlewares\Nationstech\ble_library\ns_ble_profile\uds\udsc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\uds\udsc\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\uds\udss\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\uds\udss\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\wscp;..\middlewares\Nationstech\ble_library\ns_ble_profile\wscp\wscc;..\middlewares\Nationstech\ble_library\ns_ble_profile\wscp\wscs;..\middlewares\Nationstech\ble_library\ns_ble_profile\wscp\wscc\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\wscp\wscc\src;..\middlewares\Nationstech\ble_library\ns_ble_profile\wscp\wscs\api;..\middlewares\Nationstech\ble_library\ns_ble_profile\wscp\wscs\src;..\middlewares\Nationstech\ble_library\ns_ble_stack\symdef;..\middlewares\Nationstech\ble_library\ns_ble_stack\symdef;..\BSP;..\BSP\BSP_BLE;..\DRV
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x20004000 size 0x8000
  link misc: ..\middlewares\Nationstech\ble_library\ns_ble_stack\symdef\symbol_g15.obj
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_n32wb03x.s
  group CMSIS
    ../firmware/CMSIS/device/: system_n32wb03x.c
  group FWLB
    ../firmware/n32wb03x_std_periph_driver/src/: misc.c n32wb03x_adc.c n32wb03x_crc.c n32wb03x_dma.c n32wb03x_exti.c n32wb03x_gpio.c n32wb03x_lpuart.c n32wb03x_qflash.c n32wb03x_rcc.c n32wb03x_rtc.c n32wb03x_spi.c n32wb03x_tim.c n32wb03x_usart.c n32wb03x_wwdg.c
  group BLE_STACK
    ../middlewares/Nationstech/ble_library/ns_ble_stack/stack_common/: rwip.c rwip_driver.c
    ../middlewares/Nationstech/ble_library/ns_ble_stack/ip/ble/hl/src/att/: lib_att.c
  group BLE_PROFILE
    ../middlewares/Nationstech/ble_library/ns_ble_profile/: prf.c prf_utils.c
    ../middlewares/Nationstech/ble_library/ns_ble_profile/dis/diss/src/: diss.c diss_task.c
    ../middlewares/Nationstech/ble_library/ns_ble_profile/bas/basc/src/: basc.c basc_task.c
    ../middlewares/Nationstech/ble_library/ns_ble_profile/rdts/rdtss/src/: rdtss.c rdtss_task.c
    ../middlewares/Nationstech/ble_library/ns_ble_profile/rdts/: rdts_common.c
    ../middlewares/Nationstech/ble_library/ns_ble_profile/ns_ius/ns_iuss/src/: ns_iuss.c ns_iuss_task.c
  group NS_DFU
    ../middlewares/Nationstech/ble_library/ns_library/dfu/: ns_dfu_ble.c ns_dfu_boot.c dfu_crc.c dfu_delay.c dfu_led.c dfu_usart.c
  group Crypto
    ../middlewares/Nationstech/ble_library/ns_library/ecc/: sha256.c uECC.c ns_ecc.c
  group NS_LIB
    ../middlewares/Nationstech/ble_library/ns_library/sleep/: ns_sleep.c
    ../middlewares/Nationstech/ble_library/ns_library/ble/: ns_ble.c ns_ble_task.c
    ../middlewares/Nationstech/ble_library/ns_library/sec/: ns_sec.c
    ../middlewares/Nationstech/ble_library/ns_library/error/: ns_error.c
    ../middlewares/Nationstech/ble_library/ns_library/timer/: ns_timer.c
    ../middlewares/Nationstech/ble_library/ns_library/log/: ns_log_lpuart.c ns_log_usart.c
  group BLE_APP
    ../App/src/app_profile/: app_batt.c app_dis.c app_rdtss.c app_ns_ius.c
    ../App/src/: app_ble.c
  group BSP_BLE
    ../BSP/BSP_BLE/: rs_queue_list.c rs_queue_list_config.c crc.c ble_msg.c
  group BSP
    ../BSP/: bsp_beep.c bsp_digitron.c bsp_key.c bsp_led.c bsp_relay.c bsp_alarm.c bsp_calendar.c log.c bsp_timer.c
  group USER
    ../App/src/: app_usart.c main.c
  group CONFIG
    ../App/inc/: app_user_config.h
  group DOC
    ../middlewares/Third_Party/FreeRTOS/Source/portable/: readme.txt
  group DRV
    ../DRV/: drv_soft_iic.c
target OTA_IMG_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB031 Nationstech
  pack: Nationstech.N32WB03X_DFP.1.1.0
  cpu: as above
  output: rdtss_ota
  AfterMake: fromelf --bin --output=.\bin\rdtss_ota.bin .\Objects\rdtss_ota.axf
  AfterMake: cmd.exe /C copy .\bin\rdtss_ota.bin ..\..\..\..\..\utilities\dfu\Image\APP1.bin
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: N32WB03X, USE_STDPERIPH_DRIVER, APPLICATION, BLE_OTA_ENABLE
  c include: ..\inc;..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\firmware\n32wb03x_std_periph_driver\inc;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_profile\dis\diss\api;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_profile\bas\bass\api;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_profile\hogp;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogpd\api;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogpd\src;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_profile\rdts;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_profile\rdts\rdtss\api;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_profile\ns_ius\ns_iuss\api;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ahi\api;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\api;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\inc;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\gap;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\gatt;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\l2c;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\api;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\llc;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\lld;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\llm;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\em\api;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\hci\api;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\ip\sch\api;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\aes\api;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\api;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\dbg\api;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\ecc_p256\api;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\h4tl\api;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\ke\api;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\rwip\api;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\rfinit\api;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\arch;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\api;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\src;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\stack_common;..\inc\rw;..\inc\app_profile;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\arch;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_library\adv;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_library\timer;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_library\log;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_library\delay;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_library\sleep;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_library\error;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_library\ecc;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_library\dfu;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_library\sec;..\..\..\dfu\common;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_library\ble;..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_profile\bas\bass\src
  library: MicroLIB
  memory RVCT4: ROM 0x1004000 size 0x1c000
  memory RVCT9: RAM 0x20004000 size 0x8000
  link misc: ..\..\..\..\..\middlewares\Nationstech\ble_library\ns_ble_stack\symdef\symbol_g15.obj
target OTA_IMG_2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB031 Nationstech
  pack: Nationstech.N32WB03X_DFP.1.1.0
  cpu: as above
  output: rdtss_ota
  AfterMake: as above
  AfterMake: cmd.exe /C copy .\bin\rdtss_ota.bin ..\..\..\..\..\utilities\dfu\Image\APP2.bin
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: N32WB03X, USE_STDPERIPH_DRIVER, APPLICATION, BLE_OTA_ENABLE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1020000 size 0x1c000
  memory RVCT9: RAM 0x20004000 size 0x8000
  link misc: as above
